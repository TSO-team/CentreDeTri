# IAR project 247-637 S-0001 V7.ewp, settings and files
configuration 247-637 S-0001 V7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 247-637 S-0001 V7.hex
  ILINK.IlinkOutputFile: 247-637 S-0001 V7.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/driver/communication
    ../Src/driver/communication/: driver_i2c.c driver_i2c.h piloteCAN1.c piloteCAN1.h
  group Application/User/driver/lightColumn
    ../Src/driver/lightColumn/: driver_greenLight.c driver_greenLight.h driver_redLight.c driver_redLight.h driver_yellowLight.c driver_yellowLight.h
  group Application/User/driver/onBoardButton
    ../Src/driver/onBoardButton/: driver_testButton.c driver_testButton.h
  group Application/User/driver/stepperMotor
    ../Src/driver/stepperMotor/: driver_stepperMotorA1.c driver_stepperMotorA1.h driver_stepperMotorA2.c driver_stepperMotorA2.h driver_stepperMotorB1.c driver_stepperMotorB1.h driver_stepperMotorB2.c driver_stepperMotorB2.h
  group Application/User/driver/timer
    ../Src/driver/timer/: piloteTimer6Up.c piloteTimer6Up.h
  group Application/User/driver/triac
    ../Src/driver/triac/: driver_passingByZero.c driver_passingByZero.h driver_triac.c driver_triac.h
  group Application/User/interface/carteIO
    ../Src/interface/carteIO/: interface_mcp3021.c interface_mcp3021.h interface_pcf8574A.c interface_pcf8574A.h
  group Application/User/interface/carteTriac
    ../Src/interface/carteTriac/: interface_stepperMotor.c interface_stepperMotor.h interface_triac.c interface_triac.h
  group Application/User/interface/lightColumn
    ../Src/interface/lightColumn/: interface_greenLight.c interface_greenLight.h interface_redLight.c interface_redLight.h interface_yellowLight.c interface_yellowLight.h
  group Application/User/process/centreDeTri
    ../Src/process/centreDeTri/: process_centreDeTri.c process_centreDeTri.h
  group Application/User/process/centreDeTri/modeActif
    ../Src/process/centreDeTri/modeActif/: process_modeActif.c process_modeActif.h
  group Application/User/process/centreDeTri/modeArret
    ../Src/process/centreDeTri/modeArret/: process_modeArret.c process_modeArret.h
  group Application/User/process/centreDeTri/modeAttente
    ../Src/process/centreDeTri/modeAttente/: process_modeAttente.c process_modeAttente.h
  group Application/User/process/centreDeTri/modeErreur
    ../Src/process/centreDeTri/modeErreur/: process_modeErreur.c process_modeErreur.h
  group Application/User/process/centreDeTri/modeInit
    ../Src/process/centreDeTri/modeInit/: process_modeInit.c process_modeInit.h
  group Application/User/process/centreDeTri/modeTest
    ../Src/process/centreDeTri/modeTest/: process_modeTest.c process_modeTest.h
  group Application/User/service/appInput
    ../Src/service/appInput/: service_applicationInputHandler.c service_applicationInputHandler.h
  group Application/User/service/appOutput
    ../Src/service/appOutput/: service_applicationOutputHandler.c service_applicationOutputHandler.h
  group Application/User/service/baseDeTemps
    ../Src/service/baseDeTemps/: serviceBaseDeTemps.c serviceBaseDeTemps.h
  group Application/User/service/button
    ../Src/service/button/: service_buttonUtils.c service_buttonUtils.h
  group Application/User/service/communication
    ../Src/service/communication/: service_can.c service_can.h
  group Application/User/service/lightHandling/machine
    ../Src/service/lightHandling/machine/: service_lightHandler.c service_lightHandler.h
  group Application/User/service/lightHandling/state/blinkOff
    ../Src/service/lightHandling/state/blinkOff/: service_lightHandlerBlinkOff.c service_lightHandlerBlinkOff.h
  group Application/User/service/lightHandling/state/blinkOn
    ../Src/service/lightHandling/state/blinkOn/: service_lightHandlerBlinkOn.c service_lightHandlerBlinkOn.h
  group Application/User/service/lightHandling/state/off
    ../Src/service/lightHandling/state/off/: service_lightHandlerOff.c service_lightHandlerOff.h
  group Application/User/service/lightHandling/state/on
    ../Src/service/lightHandling/state/on/: service_lightHandlerOn.c service_lightHandlerOn.h
  group Application/User/service/math
    ../Src/service/math/: service_bitOperation.c service_bitOperation.h
  group Application/User/service/stateMachine
    ../Src/service/stateMachine/: service_stateMachine.c service_stateMachine.h
  group Application/User/service/stateMachine/test/machine
    ../Src/service/stateMachine/test/machine/: service_stateMachineTest.c service_stateMachineTest.h
  group Application/User/service/stateMachine/test/state/off
    ../Src/service/stateMachine/test/state/off/: service_stateMachineTestOffState.c service_stateMachineTestOffState.h
  group Application/User/service/stateMachine/test/state/on
    ../Src/service/stateMachine/test/state/on/: service_stateMachineTestOnState.c service_stateMachineTestOnState.h
  group Application/User/service/stepperMotor
    ../Src/service/stepperMotor/: service_stepperMotor.c service_stepperMotor.h service_vacuumStepper.c service_vacuumStepper.h
  group Application/User/service/triac
    ../Src/service/triac/: service_triac.c service_triac.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
