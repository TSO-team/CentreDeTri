# IAR project Backup of MiniProjet5e.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Maxim (Dallas Semiconductor)\DS89C450.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Includes
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Maxim (Dallas Semiconductor)\lnk51ew_DS89C450.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 0
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group Application
    ../Sources/: main.c
  group Support
    ../Sources/: 8574.C Boutons.c bsp.c I2C.c Interruption.c Lcd.c Leds.c
